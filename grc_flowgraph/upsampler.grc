options:
  parameters:
    generate_options: hb
    id: upsampler
    output_language: python
    title: upsampler
  states: {}

blocks:
- name: binary_byte_input
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: binary_byte_output_upsampled
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: upsample_factor
    taps: '[0,1]'
    type: fff
  states: {}
- name: upsample_factor
  id: parameter
  parameters:
    label: upsample_factor
    type: intx
    value: '16'
  states: {}

connections:
- [binary_byte_input, '0', blocks_char_to_float_0, '0']
- [blocks_char_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_char_0, '0', binary_byte_output_upsampled, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
