options:
  parameters:
    generate_options: hb
    id: BPSK
    output_language: python
    title: BPSK
  states: {}

blocks:
- name: add
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: char2float
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: complexbpsk
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: imag_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: in_binary_data_byte
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: out_complex_bpsk_mod_data
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}

connections:
- [add, '0', complexbpsk, '0']
- [char2float, '0', add, '0']
- [complexbpsk, '0', out_complex_bpsk_mod_data, '0']
- [imag_0, '0', complexbpsk, '1']
- [in_binary_data_byte, '0', char2float, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
