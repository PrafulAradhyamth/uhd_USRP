options:
  parameters:
    generate_options: qt_gui
    id: Singlecarrierphy
    output_language: python
    title: Singlecarrierphy
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: BPSK_modulator
  id: BPSK
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: random_binary_source
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}

connections:
- [BPSK_modulator, '0', qtgui_time_sink_x_0, '0']
- [random_binary_source, '0', BPSK_modulator, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
