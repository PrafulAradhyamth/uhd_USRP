options:
  parameters:
    generate_options: qt_gui
    id: Singlecarrierphy
    output_language: python
    title: Singlecarrierphy
  states: {}

blocks:
- name: padding
  id: variable
  parameters:
    value: '[0]*32'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1]*2'
  states: {}
- name: rrc
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1'
    ntaps: sps
    samp_rate: samp_rate
    sym_rate: sps*upsample_factor
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: upsample_factor
  id: variable
  parameters:
    value: '16'
  states: {}
- name: BPSK_modulator
  id: BPSK
  parameters: {}
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (len(preamble), len(padding))
    type: byte
  states: {}
- name: data_upsampler
  id: upsampler
  parameters:
    upsample_factor: upsample_factor
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps*upsample_factor
    taps: rrc
    type: ccc
  states: {state: bypassed}
- name: padding_vector
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: padding
  states: {}
- name: preamble_vector
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: preamble
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10000'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [BPSK_modulator, '0', interp_fir_filter_xxx_0, '0']
- [blocks_stream_mux_0, '0', data_upsampler, '0']
- [data_upsampler, '0', BPSK_modulator, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [padding_vector, '0', blocks_stream_mux_0, '1']
- [preamble_vector, '0', blocks_stream_mux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
